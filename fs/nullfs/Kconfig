## fs/nullfs/Kconfig
```kconfig
config NULL_FS
	bool "NULL FS file system support"
	default y
	help
		NULL FS is a virtual file system that behaves like /dev/null
```
